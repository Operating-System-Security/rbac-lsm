## Linux/security/rbac/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0-only
config SECURITY_RBAC
	bool "RBAC support"
	depends on SECURITY
	default n
	help
	  This selects RBAC
```
